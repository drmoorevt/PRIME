# Keil uVision project PEGMARev0.uvproj, settings and files
target PEGMARev0 (ARM-ADS)
  device: STM32F205VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PEGMARev0
  c flags: Optim=1
  c define: HSE_VALUE=4000000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group header
    ../header/: adc.h analog.h dac.h eeprom.h gpio.h hih613x.h main.h serialflash.h spi.h tests.h time.h types.h uart.h util.h sdcard.h i2c.h i2cbb.h crc.h
  group lib
    ../lib/: arm_common_tables.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h stm32f2xx.h
  group system
    ../system/: system_stm32f2xx.c system_stm32f2xx.h
  group startup
    ../startup/: startup_stm32f2xx.s
  group source
    ../source/: adc.c analog.c dac.c eeprom.c hih613x.c gpio.c main.c serialflash.c spi.c tests.c time.c uart.c util.c sdcard.c i2c.c i2cbb.c crc.c
