# Keil uVision project PRIME.uvprojx, settings and files
target PRIME (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PRIME
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\Src\Fonts;..\Src\BSP\STM32F429I-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c powercon.c analog.c analog.h extusb.c eeprom.c eeprom.h time.c time.h spi.c spi.h util.c util.h m25px.c m25px.h sst26.c sst26.h types.h plr5010d.c plr5010d.h sdcard.c sdcard.h crc.c crc.h
    ../Src/BSP/STM32F429I-Discovery/: stm32f429i_discovery_lcd.c stm32f429i_discovery_ts.c stm32f429i_discovery_lcd.h stm32f429i_discovery_ts.h stm32f429i_discovery.c stm32f429i_discovery.h
    ../Src/BSP/Components/ili9341/: ili9341.c ili9341.h
    ../Src/BSP/Components/stmpe811/: stmpe811.c stmpe811.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_usb.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_adc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_spi.c stm32f4xx_hal_dac.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
software components: CMSIS:CORE 4.1.0
