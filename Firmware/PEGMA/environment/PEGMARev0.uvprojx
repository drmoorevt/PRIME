# Keil uVision project PEGMARev0.uvprojx, settings and files
target PEGMARev0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PEGMARev0
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=4000000,__CC_ARM
  c misc: -Ospace
  c include: ..\header;..\lib;..\lib\STM32_USB_Config;..\lib\STM32_USB_OTG_Driver\inc;..\lib\STM32_USB_Device_Library\Core\inc;..\lib\STM32_USB_Device_Library\Class\cdc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group header
    ../header/: adc.h analog.h bluetooth.h crc.h dac.h dma.h eeprom.h esp8266.h fsmc.h gpio.h hih613x.h i2c.h i2cbb.h main.h misc.h rcc.h sdcard.h serialflash.h spi.h sram.h tests.h time.h types.h uart.h usbvcp.h util.h zigbee.h
  group lib
    ../lib/: arm_common_tables.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h stm32f2xx.h
  group system
    ../system/: system_stm32f2xx.c system_stm32f2xx.h
  group startup
    ../startup/: startup_stm32f2xx.s
  group source
    ../source/: adc.c analog.c bluetooth.c crc.c dac.c dma.c eeprom.c esp8266.c fsmc.c gpio.c hih613x.c i2c.c i2cbb.c main.c misc.c rcc.c sdcard.c serialflash.c spi.c sram.c tests.c time.c uart.c usbvcp.c util.c zigbee.c
  group USB Config
    ../lib/STM32_USB_Config/: usb_bsp.c usbd_desc.c
  group USB Driver
    ../lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../lib/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
