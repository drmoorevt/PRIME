# Keil uVision project anteprime.uvproj, settings and files
target AntePrime (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: anteprime
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429xx
  c include: ..\header;..\library\BSP\STM32F429I-Discovery;..\library\BSP\Components;..\library\CMSIS\Device\ST\STM32F4xx\Include;..\library\CMSIS\Include;..\library\CMSIS\Lib\ARM;..\library\STM32F4xx_HAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group source
    ../source/: main.c analog.c extmem.c plr5010d.c
  group header
    ../header/: main.h stm32f4xx_hal_conf.h types.h analog.h extmem.h plr5010d.h
  group startup
    ../startup/: startup_stm32f429xx.s
  group system
    ../system/: system_stm32f4xx.c
  group BSP
    ../library/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_gyroscope.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group HAL
    ../library/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dac.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_dac_ex.c
  group Components
    ../library/BSP/Components/l3gd20/: l3gd20.c
    ../library/BSP/Components/stmpe811/: stmpe811.c
    ../library/BSP/Components/ili9341/: ili9341.c
    ../library/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim_ex.c
