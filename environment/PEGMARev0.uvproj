# Keil uVision project PEGMARev0.uvproj, settings and files
target PEGMARev0 (ARM-ADS)
  device: STM32F205VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PEGMARev0
  c flags: Optim=1
  c define: HSE_VALUE=4000000
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group source
    ../source/: adc.c analog.c dac.c eeprom.c gpio.c main.c spi.c tests.c time.c uart.c util.c
  group header
    ../header/: adc.h analog.h dac.h eeprom.h gpio.h main.h spi.h tests.h time.h types.h uart.h util.h
  group startup
    ../startup/: startup_stm32f2xx.s
  group system
    ../system/: system_stm32f2xx.c
  group lib
    ../lib/: stm32f2xx.h
